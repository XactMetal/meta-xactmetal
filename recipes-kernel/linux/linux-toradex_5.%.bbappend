FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://defconfig"
KBUILD_DEFCONFIG = "file://defconfig"
